# Autodesk Inventor part: Kuppel-2-Rahmen
## iProperties
Created: 2008-01
Part Number: Kuppel-2-Rahmen
Document SubType Name: Modeling
Designer: sec
Density: 1 g/cm^3
Author: sec
